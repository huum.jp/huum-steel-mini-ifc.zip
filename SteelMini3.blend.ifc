Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SteelMini3.blend.ifc
Time: 2023-04-06T14:24:15+03:00
Written by: IfcOpenShell v0.7.0-476ab506d
Made in: BlenderBIM 0.0.230304
Authorization: Nobody

# IfcActuator (217)
PredefinedType: ELECTRICACTUATOR
Name
30 x 1
32 x 2
26 x 3
31 x 4
33 x 5
30 x 6
34 x 7
Compound
